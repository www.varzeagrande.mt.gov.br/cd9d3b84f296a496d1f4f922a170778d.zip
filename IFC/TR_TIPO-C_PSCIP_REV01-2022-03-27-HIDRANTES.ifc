Properties of the parts of a building model (IFC4)

# File
Description: IFC4
Time: 2022-03-27T19:43:21
Made in: IfcPlusPlus

# IfcBuildingStorey, PAV. TÉRREO
LongName: PAV. TÉRREO; Elevation: 20 cm

# IfcFireSuppressionTerminal: Hidrante - mangueira 2.1/2 - 30m (4)
In: PAV. TÉRREO
Type - PredefinedType: FIREHYDRANT
Pset_AltoQi_QiBuilder - Comprimento da mangueira: 3000 cm; Diâmetro da mangueira: 6.3 cm; Diâmetro do esguicho: 1.6 cm; Comprimento: 60 cm; Largura: 17 cm; Profundidade: 90 cm; Indicação: requinte 2.1/2 - 38 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: requinte 2.1/2 - 38 mm; Descrição: Hidrante - mangueira 2.1/2 - 30m; Aplicação: Hidrante; Classe: Incêndio; Tipo: Hidrante - mangueira 2.1/2 - 30m; Rede: Hidrantes
Pset_AltoQi_QiBuilder_Item_01 - Descrição: Incêndio - Adaptador storz - roscas interna - 2.1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 2632
Pset_AltoQi_QiBuilder_Item_02 - Descrição: Incêndio - Caixa para abrigo de mangueiras - 90 x 60 x 17 cm; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 30478
Pset_AltoQi_QiBuilder_Item_03 - Descrição: Incêndio - Chave para conexão de mangote tipo rosca - pino - Dupla - 1.1/2" x 2.1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 360
Pset_AltoQi_QiBuilder_Item_04 - Descrição: Incêndio - Esguicho jato regulável - 2.1/2 38 mm; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 3284
Pset_AltoQi_QiBuilder_Item_05 - Descrição: Incêndio - Mangueiras - 2.1/2 " 30 m; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 1316
Pset_AltoQi_QiBuilder_Item_06 - Descrição: Incêndio - Niple paralelo em ferro maleável - 2.1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 1249
Pset_AltoQi_QiBuilder_Item_07 - Descrição: Incêndio - Registro globo - 2 1/2" 45º; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 1542
Pset_AltoQi_QiBuilder_Item_08 - Descrição: Incêndio - Tampão cego com corrente tipo storz - 2.1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 1534
Name
Hi1
Hi2
Hi3
Hi4

# IfcFireSuppressionTerminal: Hidrante de Recalque de Parede, HiR1
In: PAV. TÉRREO
Type - PredefinedType: FIREHYDRANT
Pset_AltoQi_QiBuilder - Comprimento da mangueira: 3000 cm; Diâmetro da mangueira: 6.3 cm; Diâmetro do esguicho: 1.6 cm; Comprimento: 60 cm; Largura: 17 cm; Profundidade: 90 cm; Indicação: 2.1/2; Posição: Direta
Pset_Identificação_Elemento - Nome: 2.1/2; Descrição: Hidrante de Recalque de Parede; Aplicação: Hidrante; Classe: Incêndio; Tipo: Hidrante de Recalque de Parede; Rede: Hidrantes
Pset_AltoQi_QiBuilder_Item_01 - Descrição: Ferro maleável classe 10 - Curva macho - fêmea - 2.1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 838
Pset_AltoQi_QiBuilder_Item_02 - Descrição: Incêndio - Adaptador storz - roscas interna - 2.1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 2632
Pset_AltoQi_QiBuilder_Item_03 - Descrição: Incêndio - Caixa para abrigo de mangueiras - 90 x 60 x 17 cm; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 30478
Pset_AltoQi_QiBuilder_Item_04 - Descrição: Incêndio - Registro de gaveta com haste ascendente de bronze - 2 1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 1374
Pset_AltoQi_QiBuilder_Item_05 - Descrição: Incêndio - Tampão cego com corrente tipo storz - 2.1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 1534

# IfcPipeFitting: Cotovelo 45 (4)
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Indicação: 2.1/2"; Posição: Direta
Pset_Identificação_Elemento - Nome: 2.1/2"; Descrição: Cotovelo 45; Aplicação: Conexão; Classe: Ferro maleável classe 10; Tipo: Cotovelo 45; Rede: Hidrantes
Pset_AltoQi_QiBuilder_Item_01 - Descrição: Ferro maleável classe 10 - Cotovelo 45 - 2.1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 1976

# IfcPipeFitting: Cotovelo 90 (19)
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Indicação: 2.1/2"; Posição: Direta
Pset_Identificação_Elemento - Nome: 2.1/2"; Descrição: Cotovelo 90; Aplicação: Conexão; Classe: Ferro maleável classe 10; Tipo: Cotovelo 90; Rede: Hidrantes
Pset_AltoQi_QiBuilder_Item_01 - Descrição: Ferro maleável classe 10 - Cotovelo 90 - 2.1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 1073
Name
18 x 
HI-1

# IfcPipeFitting: Te (7)
In: PAV. TÉRREO
Type - PredefinedType: JUNCTION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Te; Aplicação: Conexão; Classe: Ferro maleável classe 10; Tipo: Te; Rede: Hidrantes
Pset_AltoQi_QiBuilder_Item_01 - Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo
Name | Indicação = Nome | Descrição | Código do item
2 x  | 3" | Ferro maleável classe 10 - Tê - 3" | 171
5 x  | 2.1/2" | Ferro maleável classe 10 - Tê - 2.1/2" | 170

# IfcPipeFitting: Tomada dágua p/ caixa de concreto 150mm (2)
In: PAV. TÉRREO
Type - PredefinedType: ENTRY
Pset_AltoQi_QiBuilder - Indicação: 2.1/2"; Posição: Direta
Pset_Identificação_Elemento - Nome: 2.1/2"; Descrição: Tomada dágua p/ caixa de concreto 150mm; Aplicação: Tomada d´água; Classe: Ferro maleável classe 10; Tipo: Tomada dágua p/ caixa de concreto 150mm; Rede: Hidrantes
Pset_AltoQi_QiBuilder_Item_01 - Descrição: Ferro maleável classe 10 - Adapt. p/ cx. d´agua de concreto 150 mm - 2.1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 1655

# IfcPipeSegment: Tubos (46)
In: PAV. TÉRREO
Type - PredefinedType: RIGIDSEGMENT
Pset_AltoQi_QiBuilder - Comprimento máximo: 600 cm; Diâmetro interno: 6 cm; Diâmetro: ø2 1/2"; Espessura: 0.375 cm; Indicação: 65 mm
Pset_Identificação_Elemento - Nome: 2 1/2"; Classe: Ferro maleável classe 10; Tipo: Tubos; Rede: Hidrantes; Aplicação: Circular
Pset_PipeSegmentTypeCommon - InnerDiameter: 6 cm; NominalDiameter: ø2 1/2"
Name | Comprimento (cm) | Descrição | Quantidade (cm) | Fabricante = Tabela de referência | Categoria | Código do item
 | 14.22 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 14.2175 | AltoQi | Insumo | 248
 | 41.33 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 41.3337 | AltoQi | Insumo | 248
 | 43.7 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 43.7016 | AltoQi | Insumo | 248
 | 8.93 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 8.92629 | AltoQi | Insumo | 248
3 x  | 30.67 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 30.67 | AltoQi | Insumo | 248
3 x  | 178.34 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 178.34 | AltoQi | Insumo | 248
 | 834.04 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 834.04 | AltoQi | Insumo | 248
2 x  | 55.67 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 55.67 | AltoQi | Insumo | 248
 | 74.66 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 74.6573 | AltoQi | Insumo | 248
 | 279.63 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 279.627 | AltoQi | Insumo | 248
 | 20.67 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 20.67 | AltoQi | Insumo | 248
 | 591.34 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 591.34 | AltoQi | Insumo | 248
2 x  | 4.71 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 4.71 | AltoQi | Insumo | 248
 | 282.21 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 282.207 | AltoQi | Insumo | 248
2 x  | -5.17 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | -5.17 | AltoQi | Insumo | 248
 | 45.77 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 45.77 | AltoQi | Insumo | 248
 | 95.77 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 95.77 | AltoQi | Insumo | 248
 | 14.71 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 14.71 | AltoQi | Insumo | 248
 | 1.46 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 1.46 | AltoQi | Insumo | 248
 | 178.44 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 178.44 | AltoQi | Insumo | 248
2 x  | 4.04 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 4.04 | AltoQi | Insumo | 248
 | 121.44 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 121.44 | AltoQi | Insumo | 248
 | 197.83 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 197.834 | AltoQi | Insumo | 248
 | 83.03 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 83.0343 | AltoQi | Insumo | 248
 | 3401.61 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 3401.61 | AltoQi | Insumo | 248
 | 897.79 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 897.793 | AltoQi | Insumo | 248
 | -0.19
 | 2586.34 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 2586.34 | AltoQi | Insumo | 248
 | 1421.34 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 1421.34 | AltoQi | Insumo | 248
 | 1951.52 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 1951.52 | AltoQi | Insumo | 248
2 x  | 40.85 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 40.85 | AltoQi | Insumo | 248
 | 339.35 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 339.35 | AltoQi | Insumo | 248
 | 1911.34 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 1911.34 | AltoQi | Insumo | 248
 | 1345.93 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 1345.93 | AltoQi | Insumo | 248
 | 223.94 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 223.94 | AltoQi | Insumo | 248
 | 14.22 | Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2" | 14.22 | AltoQi | Insumo | 248
 | 0.97

# IfcPump: 2.1/2" x 2.1/2" (2)
In: PAV. TÉRREO
Type - PredefinedType: VERTICALINLINE
Pset_AltoQi_QiBuilder - Modelo: BPI-21 R/F 2.1/2 (123 mm) - 3 CV; Potência (CV): 3; Comprimento: 43.9 cm; Diâmetro: 14 cm; Indicação: 3CV R123; Posição: Direta
Pset_Identificação_Elemento - Nome: 3CV R123; Descrição: 2.1/2" x 2.1/2"; Aplicação: Bomba hidráulica; Classe: Bomba Hidráulica - Incêndio; Tipo: 2.1/2" x 2.1/2"; Rede: Hidrantes
Pset_AltoQi_QiBuilder_Item_01 - Descrição: Bomba Hidráulica - Incêndio - Bombas Schneider - BPI-21 R/F 2.1/2 - 123 mm - 3 CV; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 3105
Name
Bh1
Bh2

# IfcValve: Registro bruto de gaveta industrial (5)
In: PAV. TÉRREO
Type - PredefinedType: ISOLATING
Pset_AltoQi_QiBuilder - Indicação: RG; Posição: Direta
Pset_Identificação_Elemento - Nome: 2.1/2"; Descrição: Registro bruto de gaveta industrial; Aplicação: Registro; Classe: Ferro maleável classe 10; Tipo: Registro bruto de gaveta industrial; Rede: Hidrantes
Pset_AltoQi_QiBuilder_Item_01 - Descrição: Ferro maleável classe 10 - Niple duplo - 2.1/2"; Quantidade: 2; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 633
Pset_AltoQi_QiBuilder_Item_02 - Descrição: Metais - Registro bruto de gaveta industrial - 2.1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 1855

# IfcValve: Válvula de retençao horizontal c/ FºGº (2)
In: PAV. TÉRREO
Type - PredefinedType: CHECK
Pset_AltoQi_QiBuilder - Indicação: VR; Posição: Direta
Pset_Identificação_Elemento - Nome: 2.1/2"; Descrição: Válvula de retençao horizontal c/ FºGº; Aplicação: Registro; Classe: Ferro maleável classe 10; Tipo: Válvula de retençao horizontal c/ FºGº; Rede: Hidrantes
Pset_AltoQi_QiBuilder_Item_01 - Descrição: Ferro maleável classe 10 - União ass. de ferro conico macho-fêmea - 2.1/2"; Quantidade: 2; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 2618
Pset_AltoQi_QiBuilder_Item_02 - Descrição: Metais - Válvula de retenção horiz c/ portinhola - 2.1/2"; Quantidade: 1; Fabricante: AltoQi; Tabela de referência: AltoQi; Categoria: Insumo; Código do item: 1344
